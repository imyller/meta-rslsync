require btsync_2.inc

LIC_FILES_CHKSUM = "file://arm/LICENSE.TXT;md5=4b2e12dbe1b2dcec6a731f5af7f0da1a"

SRC_URI[bin_armhf.md5sum] = "cfe06cc5f668b15f246cc26dcac25265"
SRC_URI[bin_armhf.sha256sum] = "6d742b61d23471d4fe2686be0f94b9a048bf83619c16dba208777ed9f4d9ba5e"

SRC_URI[bin_arm.md5sum] = "12160398a7d470dc2f9cd1f72da948b6"
SRC_URI[bin_arm.sha256sum] = "c296ae171e9dbb56dbab925feaaf9d5885c6c8f3f3bacc95c364060f4d548d75"

SRC_URI[bin_x64.md5sum] = "8a0ec249eab8265fe0b0a7e9094611b6"
SRC_URI[bin_x64.sha256sum] = "27356501010ae675df5f71fc8652db616f5a02622754670320d1d58b5e763c66"

SRC_URI[bin_i386.md5sum] = "54a823a3f36ad17d92341ae3f6cb26e2"
SRC_URI[bin_i386.sha256sum] = "026f86c360dce3ed83096eaa88b5341597e8126946b27895554a4c062b0708dd"

