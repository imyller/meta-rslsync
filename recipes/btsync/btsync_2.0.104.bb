require btsync_2.0.inc

LIC_FILES_CHKSUM = "file://LICENSE.TXT;md5=4b2e12dbe1b2dcec6a731f5af7f0da1a"

SRC_URI[md5sum] = "d9c0497bd44fb2b79c5f19ba4f47b283"
SRC_URI[sha256sum] = "fb207eee2ead71dd7b8636896d3aef59be8dc62df05a0d7e497ca2e24b70a6ed"
