require btsync_2.inc

LIC_FILES_CHKSUM = "file://LICENSE.TXT;md5=4b2e12dbe1b2dcec6a731f5af7f0da1a"

SRC_URI[bin.md5sum] = "931ba352f52dff99f09e784582200ba2"
SRC_URI[bin.sha256sum] = "ff65eeb2a7fff0e0d0613f7cc41a48389f4d4beb11f9f7b2922a6e33c90f45c9"
