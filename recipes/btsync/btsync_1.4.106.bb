require btsync.inc

LIC_FILES_CHKSUM = "file://LICENSE.TXT;md5=4b2e12dbe1b2dcec6a731f5af7f0da1a"

SRC_URI[md5sum] = "12e77cb3d1d34e2deba10ae2e3764bda"
SRC_URI[sha256sum] = "7c22b3d34edd08f492c2e6642af9c8daedc89a4ce152e4515bd541a7142e5032"

