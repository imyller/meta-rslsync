require btsync_2.inc

LIC_FILES_CHKSUM = "file://arm/LICENSE.TXT;md5=4b2e12dbe1b2dcec6a731f5af7f0da1a"

SRC_URI[bin_armhf.md5sum] = "230ed41ad6cbce2d7ab8cfa2ad84cf37"
SRC_URI[bin_armhf.sha256sum] = "1785e3ae705dd6143b7292967e02d0a3c6fe119028327898356a522a59028bed"

SRC_URI[bin_arm.md5sum] = "f4125bdafd9724f5c2246ffca2af7572"
SRC_URI[bin_arm.sha256sum] = "421a737d2c46e1fc79bd44b91c07ad260d468fd501e785a67c5972958accda4f"

SRC_URI[bin_x64.md5sum] = "48eb5aae01a8e7aae777bc93165ec560"
SRC_URI[bin_x64.sha256sum] = "a15d13f7daf14c9c38b78fd7659e982379c0b8a731d437c661367760f632dcc2"

SRC_URI[bin_i386.md5sum] = "17bfe2fc396d13b942f8b78b80828f5d"
SRC_URI[bin_i386.sha256sum] = "616392ad9420327faf5d1ac7d21be4606217cec05875186a096aab6af0b24842"

