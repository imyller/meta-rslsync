require btsync_2.inc

LIC_FILES_CHKSUM = "file://arm/LICENSE.TXT;md5=4b2e12dbe1b2dcec6a731f5af7f0da1a"

SRC_URI[bin_armhf.md5sum] = "fc5ac5995b69451b5cf1938294274b81"
SRC_URI[bin_armhf.sha256sum] = "52a8ac84d8bc0b6825dcbc6e294ce5bcf6a4b7de1c515c2777223e6f884ca670"

SRC_URI[bin_arm.md5sum] = "0b8b0b2aa4e253eacf70545c5e40d0f4"
SRC_URI[bin_arm.sha256sum] = "4c5270d03ed9f527c7802adf4d7a0d4d22ef1698e3cf031ec022a9b5b80bb796"

SRC_URI[bin_x64.md5sum] = "ee773c100fce0c50b477ca9703cfe771"
SRC_URI[bin_x64.sha256sum] = "9e1a63d7e346278f7301f149626013242a3c605db90a645ebe757c164cd1c50a"

SRC_URI[bin_i386.md5sum] = "9b04ae3fb56a09f28bfd107f375fcbe5"
SRC_URI[bin_i386.sha256sum] = "517e88773f9c1be0e1d73b4b55660339d74e9be9ae83af331875bfc3bacd1885"
