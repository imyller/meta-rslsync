require btsync_2.0.inc

LIC_FILES_CHKSUM = "file://LICENSE.TXT;md5=4b2e12dbe1b2dcec6a731f5af7f0da1a"

SRC_URI[md5sum] = "2e7423a1c2f60bb3bb7b5eaa13b16eed"
SRC_URI[sha256sum] = "abaaf0ea2fcbde3f1867c53b8d7b2eba077dcef7a0d7b0f8eb94156ce209177f"
