require btsync_2.inc

LIC_FILES_CHKSUM = "file://LICENSE.TXT;md5=4b2e12dbe1b2dcec6a731f5af7f0da1a"

SRC_URI[bin.md5sum] = "2410fd1d98c40222c292d8eeb0aecde6"
SRC_URI[bin.sha256sum] = "e68dfd610e28d76a842c6aa911860759fe50e36be7c0614df1e69d915d026836"

