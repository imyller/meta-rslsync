require btsync_2.inc

LIC_FILES_CHKSUM = "file://LICENSE.TXT;md5=4b2e12dbe1b2dcec6a731f5af7f0da1a"

SRC_URI[bin.md5sum] = "429990caa1e26e33121f5bb6947c4d7d"
SRC_URI[bin.sha256sum] = "504da016d93691ffa80a6a4b737434847c46ea08f9546aa2a1723d0aa0805c3d"
