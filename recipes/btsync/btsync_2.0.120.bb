require btsync_2.0.inc

LIC_FILES_CHKSUM = "file://LICENSE.TXT;md5=4b2e12dbe1b2dcec6a731f5af7f0da1a"

SRC_URI[md5sum] = "ecac62420f342e3a6fbcbec6986dd572"
SRC_URI[sha256sum] = "98e0300753d6019ab55c4ba655b3c7117f59b64e809dcf6987b1f7a030fe9571"
