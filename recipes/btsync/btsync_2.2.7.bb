require btsync_2.inc

LIC_FILES_CHKSUM = "file://LICENSE.TXT;md5=4b2e12dbe1b2dcec6a731f5af7f0da1a"

SRC_URI[bin.md5sum] = "47c0ecebda6dbbc0024bce8d3bcefd10"
SRC_URI[bin.sha256sum] = "80c018ba8672325deb537f77d48b383722ffa28d6ee10434d81915a79b066404"

