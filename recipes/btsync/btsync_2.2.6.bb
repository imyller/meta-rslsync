require btsync_2.inc

LIC_FILES_CHKSUM = "file://LICENSE.TXT;md5=4b2e12dbe1b2dcec6a731f5af7f0da1a"

SRC_URI[bin.md5sum] = "c8f7172b8838408b7ca4b41e0c118427"
SRC_URI[bin.sha256sum] = "31f7fcd71507430a64c202ac101d8f102ab8353788d8d3dbb2e7ba0d981f6409"
