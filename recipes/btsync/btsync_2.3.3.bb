require btsync_2.inc

LIC_FILES_CHKSUM = "file://LICENSE.TXT;md5=4b2e12dbe1b2dcec6a731f5af7f0da1a"

SRC_URI[bin.md5sum] = "8b5127442bbd8ca1f79b08ef2e2e837d"
SRC_URI[bin.sha256sum] = "38d11aa0c4ab5764227fe5b42f99fb57402455bacc8a70aba4898f78bf40fa21"
