require btsync_2.inc

LIC_FILES_CHKSUM = "file://LICENSE.TXT;md5=4b2e12dbe1b2dcec6a731f5af7f0da1a"

SRC_URI[bin.md5sum] = "39294b320886900d3ec0808691896d01"
SRC_URI[bin.sha256sum] = "e26dc163d0ac9c5ff7118e915b17cfe2bceca522e0ff09d0e8e071969d69dc22"
