require btsync_2.inc

LIC_FILES_CHKSUM = "file://LICENSE.TXT;md5=4b2e12dbe1b2dcec6a731f5af7f0da1a"

SRC_URI[bin.md5sum] = "59bec301c2a7a61a9ae5e81ef9abef09"
SRC_URI[bin.sha256sum] = "6a82b5233fbcac21e4617f2b15688c601ac1805c857ccdc0bd879e046fa29cf5"
