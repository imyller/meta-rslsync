require btsync_2.inc

LIC_FILES_CHKSUM = "file://arm/LICENSE.TXT;md5=4b2e12dbe1b2dcec6a731f5af7f0da1a"

SRC_URI[bin_armhf.md5sum] = "c44975123dbe62ecb5cf36f4b11e5ada"
SRC_URI[bin_armhf.sha256sum] = "a0fd14fe3b36fdd28aa7b58d1607e76a4c5d47e4187dba439584dc4df14c55c4"

SRC_URI[bin_arm.md5sum] = "7fda1879cb6d21e68ea8d618ad119d91"
SRC_URI[bin_arm.sha256sum] = "425b08c69b9eb88c29def0ecb6164f45a7266eb1f2db67800b573f91c5acac87"

SRC_URI[bin_x64.md5sum] = "473614add894fa56e41bfbd2d28d9511"
SRC_URI[bin_x64.sha256sum] = "6b569ca83cb57356946cdc279149ebe800cfc75482f9aff12c7e870d7debacf7"

SRC_URI[bin_i386.md5sum] = "deca1185eedfad86e2fc4440877ec48d"
SRC_URI[bin_i386.sha256sum] = "374fb2e1e57715fa543032abb69f9687302337c96867a3bbc79d3f2278c181c0"
