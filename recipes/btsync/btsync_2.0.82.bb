require btsync_2.0.inc

LIC_FILES_CHKSUM = "file://LICENSE.TXT;md5=4b2e12dbe1b2dcec6a731f5af7f0da1a"

SRC_URI[md5sum] = "c388be6f64b3ed9c7f954b9b2d22c158"
SRC_URI[sha256sum] = "b34e9791473afaf334813ab4d35fa8bb8ffa6f1d661e688f9d789d7b75ff3b61"
