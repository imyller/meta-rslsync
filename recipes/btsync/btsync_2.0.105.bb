require btsync_2.0.inc

LIC_FILES_CHKSUM = "file://LICENSE.TXT;md5=4b2e12dbe1b2dcec6a731f5af7f0da1a"

SRC_URI[md5sum] = "4b31191c068bf18f0a94cbcb2c45dfa2"
SRC_URI[sha256sum] = "c63fccb76ba3f5dd1197f33bfb8427747faaca9c030f9d8c7f5dfc016d293807"

