require btsync_2.inc

LIC_FILES_CHKSUM = "file://LICENSE.TXT;md5=4b2e12dbe1b2dcec6a731f5af7f0da1a"

SRC_URI[bin.md5sum] = "eb4cb719c5c185fb407e669e1a8b7e83"
SRC_URI[bin.sha256sum] = "a971e5b8b87804330881d5b5394267717c614e46c534deb73bd718f89739e581"

