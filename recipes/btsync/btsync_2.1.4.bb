require btsync_2.inc

LIC_FILES_CHKSUM = "file://LICENSE.TXT;md5=4b2e12dbe1b2dcec6a731f5af7f0da1a"

SRC_URI[bin.md5sum] = "3ae6bcec7c6a6b7601b73853476f1c7c"
SRC_URI[bin.sha256sum] = "a43c26dc67afc6d4d8b9d0bb510516af00eb0ca55400b65cd2938933e546f855"
