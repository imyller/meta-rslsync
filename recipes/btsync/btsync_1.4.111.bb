require btsync.inc

LIC_FILES_CHKSUM = "file://LICENSE.TXT;md5=4b2e12dbe1b2dcec6a731f5af7f0da1a"

SRC_URI[md5sum] = "de407078b9cff8bcdb31477c84a61364"
SRC_URI[sha256sum] = "552b6b400155e97180e3c5b45f3fa771192fdf9fc226679b5039ee0a9261da92"
