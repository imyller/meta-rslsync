require btsync_2.inc

LIC_FILES_CHKSUM = "file://arm/LICENSE.TXT;md5=4b2e12dbe1b2dcec6a731f5af7f0da1a"

SRC_URI[bin_armhf.md5sum] = "71cc0ac8440aa79578079883868b5141"
SRC_URI[bin_armhf.sha256sum] = "1ec781bea479be67f5a720962bca22be2cd5498d8d78c2d3fc100985289ad3c9"

SRC_URI[bin_arm.md5sum] = "51a4449f85866f40d477cbd6de80af37"
SRC_URI[bin_arm.sha256sum] = "d43f4e07efd4727df4b70b40b4cf28b56aab37871573dedcd685ff5d09df5efb"

SRC_URI[bin_x64.md5sum] = "981a2ca8484c46834abf7aea4b4b24a1"
SRC_URI[bin_x64.sha256sum] = "fac80d415aa44d9f2e027b56cb4fea1aa8770489cffc037b64fd05135fa4d907"

SRC_URI[bin_i386.md5sum] = "732af0202717e56705be37027f2cf57b"
SRC_URI[bin_i386.sha256sum] = "a7d50cf379e6c9d6c97116225a1effb2350a5a90b93a95b345f070e20ea52d85"
