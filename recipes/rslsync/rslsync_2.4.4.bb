require rslsync_2.inc

LIC_FILES_CHKSUM = "file://arm/LICENSE.TXT;md5=2214289223a7c2378b82a7eff4019567"

SRC_URI[bin_armhf.md5sum] = "02c94959e39a2de7be372e440700c87b"
SRC_URI[bin_armhf.sha256sum] = "b71fbf1f5873ddc0cc1e926356eee27b8a83d3c045a3161eaf034728076a2287"

SRC_URI[bin_arm.md5sum] = "388ea954d375cd813b18b831b6686e11"
SRC_URI[bin_arm.sha256sum] = "3a36576962f93bcefc05842f2cc7303af8a826ecb596abed4a953a7be5595532"

SRC_URI[bin_x64.md5sum] = "c01cd02a3f901e9c65dfbd18a64f1081"
SRC_URI[bin_x64.sha256sum] = "00fb4354b713cda91a55a9e84fe4a9be5241f42b5b7b6a6df52f72ea89f1c447"

SRC_URI[bin_i386.md5sum] = "d1d51ab2a264594e9af361ce58da5c7b"
SRC_URI[bin_i386.sha256sum] = "77a2b6e6c07526ad29426dcae4e5b84babd50d5d24aa3b0d93a3b3d2b5ce91d9"
