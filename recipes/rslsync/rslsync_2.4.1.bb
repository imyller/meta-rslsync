require rslsync_2.inc

LIC_FILES_CHKSUM = "file://arm/LICENSE.TXT;md5=4b2e12dbe1b2dcec6a731f5af7f0da1a"

SRC_URI[bin_armhf.md5sum] = "613bd230818f76979004308f370b417e"
SRC_URI[bin_armhf.sha256sum] = "a4023133143dd002c1ea7ae49b0c6929af0f910b7d3ac9dec0b01b4f474143ae"

SRC_URI[bin_arm.md5sum] = "47dea23b31e70c407ccfd9ce6d2d357c"
SRC_URI[bin_arm.sha256sum] = "09df8735d816b8e3d4004e8c99b6cb53d5d3b0eea0bafb1ed459e2289c9cd388"

SRC_URI[bin_x64.md5sum] = "e48a933c914c64094c0048fd9367a1d4"
SRC_URI[bin_x64.sha256sum] = "1597b39eb1e47a38240bda2e80e9579e0ff2ab0d8b99eb6d19b7e3f283456271"

SRC_URI[bin_i386.md5sum] = "4251c320e22aa5d33ae2f2110bcb6c4c"
SRC_URI[bin_i386.sha256sum] = "aefced43f9fa28e504c9a6d795914f6888545c4464b1c8803cccf02d031b1c00"

