require rslsync_2.inc

LIC_FILES_CHKSUM = "file://arm/LICENSE.TXT;md5=4b2e12dbe1b2dcec6a731f5af7f0da1a"

SRC_URI[bin_armhf.md5sum] = "6c5ccac5eb07dcdc5e0707d28ee7f2f8"
SRC_URI[bin_armhf.sha256sum] = "e809f47f2d8d0c89b7f67cc7578cec9663c19af44d857a5a0848c6a57c3759fa"

SRC_URI[bin_arm.md5sum] = "deb83f6c225166ddc7a03aff3f10a09f"
SRC_URI[bin_arm.sha256sum] = "93259316c74b7ca7ff64728c2340a0c5d5f048d2f4d50b91bdc9d02c2fb5f5ad"

SRC_URI[bin_x64.md5sum] = "80cd9a84e98a19f28cd4e24d694528c5"
SRC_URI[bin_x64.sha256sum] = "df7f3cf0d5fca711b0b97d446dd517f7a532e894ec33b7b052078d8cc8581580"

SRC_URI[bin_i386.md5sum] = "cfe0c996e0eb176cecc61d31075a7382"
SRC_URI[bin_i386.sha256sum] = "6aad4ed30027c0071392aeedafeaed850acdb58a4c18405245d55ed22e7cb28e"
