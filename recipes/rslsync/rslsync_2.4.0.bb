require rslsync_2.inc

LIC_FILES_CHKSUM = "file://arm/LICENSE.TXT;md5=4b2e12dbe1b2dcec6a731f5af7f0da1a"

SRC_URI[bin_armhf.md5sum] = "2ed2c2a95f910fbe2bbb26f668004b22"
SRC_URI[bin_armhf.sha256sum] = "ebb31c4d673b39c3e635ccb40d7742c3cd62dbb1a711485c7a25e23d64ccec56"

SRC_URI[bin_arm.md5sum] = "dbbed99b01c6281b268709bc3018849e"
SRC_URI[bin_arm.sha256sum] = "c4ab810c7cae4010130538da1321d1842d20db6d0ba4ba7f93d0ebdbf0568231"

SRC_URI[bin_x64.md5sum] = "e9f94a9ba004c73aec842e60042add2e"
SRC_URI[bin_x64.sha256sum] = "747dc13859878f0b6d011c11b172c04d37f82a64a4e4a6bb588815e005b69fda"

SRC_URI[bin_i386.md5sum] = "19cb61add36e2c03b58fb3797e1b4ea2"
SRC_URI[bin_i386.sha256sum] = "b7169bfe26b8dbcbbcb44245adb1edb7e2cdbb8bd3fa0f818e69ccdbe4b21bac"
